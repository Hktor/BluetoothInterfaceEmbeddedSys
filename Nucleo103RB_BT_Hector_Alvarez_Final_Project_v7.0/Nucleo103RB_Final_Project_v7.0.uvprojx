# Keil uVision project Nucleo103RB_Final_Project_v7.0.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NucleoF103display
  c flags: Optim=1 uC99=1 wLevel=2
  c define: GLCD_DEVICE_STM32F10X, GLCD_CONTROLLER_ST7565R, GLCD_LCD_WIDTH=128, GLCD_LCD_HEIGHT=32, GLCD_INIT_NHD_C12832A1Z_FSW_FBW_3V3
  c include: ./inc;..\Libraries\glcd;..\Libraries\glcd\fonts
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./src/: main.c stm32f10x_it.c configuration.c rtc.c mma7660.c lm75b.c display.c i2c.c BT.c Retarget.c Service_UUID.c
    ./: Definitions.txt
  group glcd
    ../Libraries/glcd/: glcd.c graphics.c graphs.c text.c text_tiny.c
    ../Libraries/glcd/controllers/: ST7565R.c
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
